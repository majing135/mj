# Keil uVision project BST Balance.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BST Balance check +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\User;.\MPU6050;..\1.9site
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./User/: main.c delay.c I2C.c I2C_MPU6050.c led.c stm32f10x_it.c systick.c usart.c timer.c bsp_spi_nrf.c DEVICE_IIC.c
    ./MPU6050/: Anyway_Kalman.c
    ./: Least Square Method.c BMA421.c
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_md.s
software components: CMSIS:CORE 4.3.0
